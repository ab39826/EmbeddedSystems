# Keil uVision project FIFO_1968.uvproj, settings and files
target FIFO (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: FIFO
  c flags: Optim=1
  c include: ..;..\..\..;..\inc;..\driverlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Sources
    ./: Startup.s FIFO.c FIFOTestMain.c drawLine.c Output.c rit128x96x4.c
  group Library
    ../driverlib/rvmdk/: driverlib.lib
