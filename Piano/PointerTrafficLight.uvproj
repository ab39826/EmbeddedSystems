# Keil uVision project PointerTrafficLight.uvproj, settings and files
target PointerTrafficLight (ARM-ADS)
  device: LM3S1968 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: PointerTrafficLight
  c flags: Optim=1
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Code
    ./: Startup.s PointerTrafficLight.c SysTick.c PLL.c buttons.c music.c DAC.c Timer0A.c
